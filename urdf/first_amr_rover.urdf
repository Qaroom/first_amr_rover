Commit message: persembe duzeltmeler

File: urdf/first_amr_rover.urdf (robot description, URDF)
Before this commit: robot first_amr_rover, 13 links, 12 joints
Links:
- link base_link: mass 150 -> 450
